# Keil uVision project MIVO.uvprojx, settings and files
target MIVO (6240000::V6.24::ARMCLANG)
  device: STM32L451RETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: MIVO +hex
  AfterMake: "C:\Users\EresensePC\AppData\Local\Keil_v5\ARM\ARMCLANG\bin\fromelf.exe" --bin --output=Output\MIVOBin Output\MIVO.axf
  AfterMake: ..\..\..\_Bin\OADCreateCfg.exe --Dwn=2 --ENRAM=1 --output=Output\MIVO_Download.cfg     Output\MIVOBin\ER_IROM1
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L451xx
  c include: ...\..\..\Drivers\SMT32L4xx_HAL\STM32L4xx_HAL_Driver\Inc\Legacy;..\..\..\Drivers\SMT32L4xx_HAL\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\Drivers\SMT32L4xx_HAL\CMSIS\Include;..\..\..\Drivers\SMT32L4xx_HAL\STM32L4xx_HAL_Driver\Src;..\..\..\Drivers\INC;..\..\..\Drivers\STM32L4xx_Dal\inc;..\..\..\Drivers\SMT32L4xx_HAL\STM32L4xx_HAL_Driver\Inc;..\..\..\Modules\Inc;..\..\..\App\MIVO;..\..\..\Drivers\INC;..\..\..\App\MIVO\Customers;C:\Keil_v5\ARM\RV31\INC
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: .\MIVO.sct
  group Customer
    ../../../App/MIVO/Customers/: CustomerEresense.h Customers.h CustomerIctas.h CustomerKalyon.h CustomersIctas_ZoneList.h
  group App
    ../../../App/MIVO/: app.h AppCompass.c AppCompass.h AppLog.c AppLog.h app.c AppMemory.c AppMemory.h AppMessage.c AppMessage.h AppPressure.c AppPressure.h AppRfid.c AppRfid.h AppRfm.c AppRfm.h AppTask.c AppTask.h AppTelemetry.c AppTelemetry.h AppVehicleTrack.c AppVehicleTrackTruck.c AppVehicleTrackLef.c AppVehicleTrack.h AppVibration.c AppVibration.h AppWakeup.c AppWakeup.h configModules.h foo.c AppLed.c AppLed.h configDrivers.h AppConfig.c AppConfig.h AppCan.c AppCan.h AppCommand.c AppCommand.h zone.c
  group Modules
    ../../../Modules/: mCommunication.c mError.c mMemory.c mTelemetry.c mUtilities.c
  group Driver_Common
    ../../../Drivers/Common/Buzzer/: dBuzzer.c
    ../../../Drivers/Common/Crc/: dCrc.c
    ../../../Drivers/Common/GprsSimcom/: dGprs.c
    ../../../Drivers/Common/GPSSimcom/: dGPS.c
    ../../../Drivers/Common/Timer/: dTimerFunc.c
    ../../../Drivers/Common/RFM/: dRFModule.c
    ../../../Drivers/Common/RFIDRC522/: dRFID.c
    ../../../Drivers/Common/Pressure/: dPressure.c
    ../../../Drivers/Common/NVM/: dNVM.c
    ../../../Drivers/Common/LSM6DSMLTR/: dLSM6DSM.c
    ../../../Drivers/Common/MyStdLib/: myStdlib.c
    ../../../Drivers/Common/RtosSim/: dRtosSim.c
    ../../../Drivers/Common/Crypto/: dCrypto.c
  group STM32L4xx_Dal
    ../../../Drivers/STM32L4xx_Dal/: dAdc.c dFlashSimple.c dGpio.c dGpioInt.c dI2c.c dRtc.c dSsp.c dTimerSystem.c dUART.c dWDT.c platform.c dUARTDma.c dUARTPoll.c dCan.c dCanInt.c
  group STM32L4xx_HAL_Driver
    ../../../Drivers/SMT32L4xx_HAL/STM32L4xx_HAL_Driver/Src/: startup_stm32l451xx.s stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_can.c stm32l4xx_hal_comp.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_cryp.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_dac.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_dcmi.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dfsdm_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_dma2d.c stm32l4xx_hal_dsi.c stm32l4xx_hal_exti.c stm32l4xx_hal_firewall.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gfxmmu.c stm32l4xx_hal_gpio.c stm32l4xx_hal_hash.c stm32l4xx_hal_hash_ex.c stm32l4xx_hal_hcd.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_irda.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_lcd.c stm32l4xx_hal_lptim.c stm32l4xx_hal_ltdc.c stm32l4xx_hal_ltdc_ex.c stm32l4xx_hal_mmc.c stm32l4xx_hal_mmc_ex.c stm32l4xx_hal_nand.c stm32l4xx_hal_nor.c stm32l4xx_hal_opamp.c stm32l4xx_hal_opamp_ex.c stm32l4xx_hal_ospi.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pka.c stm32l4xx_hal_pssi.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_rng_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_sai.c stm32l4xx_hal_sai_ex.c stm32l4xx_hal_sd.c stm32l4xx_hal_sd_ex.c stm32l4xx_hal_smartcard.c stm32l4xx_hal_smartcard_ex.c stm32l4xx_hal_smbus.c stm32l4xx_hal_smbus_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_sram.c stm32l4xx_hal_swpmi.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_tsc.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_wwdg.c stm32l4xx_ll_adc.c stm32l4xx_ll_comp.c stm32l4xx_ll_crc.c stm32l4xx_ll_crs.c stm32l4xx_ll_dac.c stm32l4xx_ll_dma.c stm32l4xx_ll_dma2d.c stm32l4xx_ll_exti.c stm32l4xx_ll_fmc.c stm32l4xx_ll_gpio.c stm32l4xx_ll_i2c.c stm32l4xx_ll_lptim.c stm32l4xx_ll_lpuart.c stm32l4xx_ll_opamp.c stm32l4xx_ll_pka.c stm32l4xx_ll_pwr.c stm32l4xx_ll_rcc.c stm32l4xx_ll_rng.c stm32l4xx_ll_rtc.c stm32l4xx_ll_sdmmc.c stm32l4xx_ll_spi.c stm32l4xx_ll_swpmi.c stm32l4xx_ll_tim.c stm32l4xx_ll_usart.c stm32l4xx_ll_usb.c stm32l4xx_ll_utils.c system_stm32l4xx.c
software components: CMSIS:CORE 6.1.0
